# Keil uVision project EmbeddedCppWithArm.uvprojx, settings and files
target STMF103C8 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EmbeddedCppWithArm +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MCAL
    ./: rcc.cpp rcc.h gpio.cpp gpio.h STD_TYPES.h
  group HAL
    ./: led.cpp led_cfg.cpp led.h led_cfg.h
  group APP
    ./: main.cpp
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
